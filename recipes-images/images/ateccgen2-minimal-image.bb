require ateccgen2-base-image.inc

SUMMARY = "NI ATE Core Configurations Gen 2 RCU Image"
DESCRIPTION = "NI ATE Core Configurations Gen 2 RCU image"

IMAGE_INSTALL += " \
    packagegroup-base-ni-cli \
"
