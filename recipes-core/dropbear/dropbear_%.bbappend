# Disable Dropbear SSH server by default
SYSTEMD_AUTO_ENABLE = "disable"
