FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://alter-default-apalis-device-tree.patch "
