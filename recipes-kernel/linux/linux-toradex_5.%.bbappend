FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://smartracks.cfg"
